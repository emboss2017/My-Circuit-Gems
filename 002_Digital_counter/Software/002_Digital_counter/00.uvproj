# Keil uVision project 00.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 00 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\delay;.\Basic\i2c;.\Basic\rtc;.\Basic\sys;.\Basic\usart;.\Hardware\KEY;.\Hardware\LED;.\Hardware\OLED0561;.\Hardware\RELAY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c delay.h
    ./Basic/i2c/: i2c.c i2c.h
    ./Basic/rtc/: rtc.c rtc.h
    ./Basic/sys/: sys.c sys.h
    ./Basic/usart/: usart.c usart.h
  group Hardware
    ./Hardware/KEY/: key.c key.h
    ./Hardware/LED/: led.c led.h
    ./Hardware/OLED0561/: ASCII_8x16.h CHS_16x16.h oled0561.c oled0561.h PIC1.h
    ./Hardware/RELAY/: relay.c relay.h
